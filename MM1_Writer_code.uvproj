# Keil uVision project MM1_Writer_code.uvproj, settings and files
target MM1_Writer (MCS-51)
  device: C8051F381 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: MM1_Writer_code
  c flags: SizeSpeed=1
  group Sources
    ./: STARTUP.A51 config.c main.c uart.c memory.c
  group Headers
    ./: config.h main.h uart.h memory.h
